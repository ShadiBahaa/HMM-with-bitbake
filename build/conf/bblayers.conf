## build/conf/bblayers.conf
```bitbake
BBPATH := "${TOPDIR}"
BBFILES ?= ""
BBLAYERS = " \
  ${TOPDIR}/../meta-static \
  ${TOPDIR}/../meta-dynamic \
  ${TOPDIR}/../meta-test \
"
```
